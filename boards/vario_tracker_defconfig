## boards/vario_tracker_defconfig
```kconfig
# Custom board default config
CONFIG_SOC_SERIES_NRF52X=y
CONFIG_SOC_NRF52833_QDAA=y
CONFIG_BOARD_VARIO_TRACKER=y
```
